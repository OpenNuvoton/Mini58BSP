# IAR project SYS_PowerDown_MinCurrent.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: Mini58DE series Nuvoton Mini58DE series
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCIncludePath2: ..\..\..\..\Library\CMSIS\Include; ..\..\..\..\Library\Device\Nuvoton\Mini58Series\Include; ..\..\..\..\Library\StdDriver\inc
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: SYS_PowerDown_MinCurrent.bin
  ILINK.IlinkOutputFile: SYS_PowerDown_MinCurrent.out
  ILINK.IlinkProgramEntryLabel: Reset_Handler
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  OBJCOPY.OOCOutputFile: GPIO.bin
  ILINK.IlinkOutputFile: GPIO.out
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini58Series/Source/IAR/: startup_Mini58Series.s
    ../../../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c gpio.c retarget.c sys.c uart.c
  group User
    ../: main.c

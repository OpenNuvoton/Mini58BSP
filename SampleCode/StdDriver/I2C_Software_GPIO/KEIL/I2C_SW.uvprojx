# Keil uVision project I2C_SW.uvprojx, settings and files
target I2C_SW (6150000::V6.15::ARMCLANG)
  device: Mini58LDE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: I2C_SW
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\Device\Nuvoton\Mini58Series\Include;..\..\..\..\Library\StdDriver\inc
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group User
    ../: main.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c sys.c uart.c retarget.c i2c.c gpio.c
    ../: i2c_hardware.c i2c_software_gpio.c

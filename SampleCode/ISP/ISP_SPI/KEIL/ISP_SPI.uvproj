# Keil uVision project ISP_SPI.uvproj, settings and files
target ISP_SPI (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Mini58LDE Nuvoton
  cpu: IRAM(0x20000000-0x20000FFF) IROM(0-0x7FFF) CLOCK(50000000) CPUTYPE("Cortex-M0")
  output: Mini58_ISP_SPI
  AfterMake: fromelf --bin ".\obj\@L.axf" --output ".\obj\@L.bin"
  AfterMake: fromelf --text -c ".\obj\@L.axf" --output ".\obj\@L.txt"
  c flags: Optim=3 v6Lang=1 v6LangP=1 wLevel=2
  c define: TARGET_Mini51
  c include: ..\..\..\..\Library\CMSIS\Include;..\..\..\..\Library\StdDriver\inc;..\..\..\..\Library\Device\Nuvoton\Mini58Series\Include
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x20000000 size 0x1000
  link misc: --map --first='startup_Mini58Series.o(RESET)' --datacompressor=off --info=inline --entry Reset_Handler
  group CMSIS
    ../../../../Library/Device/Nuvoton/Mini58Series/Source/: system_Mini58Series.c
    ../../../../Library/Device/Nuvoton/Mini58Series/Source/ARM/: startup_Mini58Series.s
  group User
    ../: main.c fmc_user.c isp_user.c targetdev.c spi_transfer.c
  group Library
    ../../../../Library/StdDriver/src/: clk.c fmc.c gpio.c spi.c sys.c timer.c
